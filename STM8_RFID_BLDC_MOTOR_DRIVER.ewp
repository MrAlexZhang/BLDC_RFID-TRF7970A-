# IAR project STM8_RFID_BLDC_MOTOR_DRIVER.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208R8 STM8S208R8
  General.GenCodeModel: 1
  General.GenDataModel: 2
  General.GenStackSize: 0x500
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: LIB\inc; LIB\SRC; RFID; USER; motor_driver; inoutport; stm8_mc_library\MC_FWLIB_SCALAR\inc; stm8_mc_library\MC_FWLIB_SCALAR\param; stm8_mc_library\STM8_MC_FRAMEWORK\inc; stm8_mc_library\STM8_MC_FRAMEWORK\param; 
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8_RFID_BLDC_MOTOR_DRIVER.bin
  ILINK.IlinkOutputFile: STM8_RFID_BLDC_MOTOR_DRIVER.out
  ILINK.IlinkIcfFile: lnkstm8s208r8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group inoutport
    inoutport/: inoutport.c
  group LIB
    LIB/src/: stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_wwdg.c
  group motor_driver
    motor_driver/: BLDCcontral.c Motorcontral.c
  group RFID
    RFID/: felica.c highdata.c host.c initiator.c iso14443a.c iso14443b.c iso15693.c nfc.c parallel.c spi.c tag.c target.c trf797x.c type2.c uart.c
  group stm8_mc_library/MC_FWLIB_SCALAR
    stm8_mc_library/MC_FWLIB_SCALAR/src/: MC_BLDC_Drive.c MC_BLDC_Motor.c MC_BLDC_User_Interface.c MC_dev.c MC_display.c MC_Keys.c MC_pid_regulators.c MC_StateMachine.c MC_tacho.c MC_User_Interface.c MC_vtimer.c
  group stm8_mc_library/STM8_MC_FRAMEWORK
    stm8_mc_library/STM8_MC_FRAMEWORK/src/: MC_stm8s_BLDC_drive.c MC_stm8s_clk.c MC_stm8s_DAC.c MC_stm8s_display.c MC_stm8s_keys.c MC_stm8s_lcd.c MC_stm8s_opt.c MC_stm8s_port.c MC_stm8s_vtimer.c stm8_interrupt_vector.c vdev.c vdev_callbacks.c vdev_ios.c
  group USER
    USER/: can.c Main.c SystemInit.C
